# Keil uVision project ble_app_uart_s132_pca10040.uvprojx, settings and files
target nrf52832_xxaa_s132 (ARM-ADS)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.6.1
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(64000000) ELITTLE
  output: longcheer_Pager +hex
  c flags: Optim=4 OneElfS=1 uC99=1
  c define: BLE_STACK_SUPPORT_REQD BOARD_PCA10040 NRF52_PAN_12 NRF52_PAN_15 NRF52_PAN_20 NRF52_PAN_30 NRF52_PAN_31 NRF52_PAN_36 NRF52_PAN_51 NRF52_PAN_53 NRF52_PAN_54 NRF52_PAN_55 NRF52_PAN_58 NRF52_PAN_62 NRF52_PAN_63 NRF52_PAN_64 CONFIG_GPIO_AS_PINRESET S132 NRF_LOG_USES_UART=1 NRF52 SOFTDEVICE_PRESENT SWI_DISABLE0 CONFIG_PLATFORM_NRFS CONFIG_KERNEL_SYSTEM CONFIG_PLATFORM_NRFS CONFIG_NFCT_PINS_AS_GPIOS
  c include: ..\..\..\config\ble_app_uart_s132_pca10040;..\..\..\config;..\..\..\..\..\..\components\ble\ble_advertising;..\..\..\..\..\..\components\ble\ble_services\ble_nus;..\..\..\..\..\..\components\ble\common;..\..\..\..\..\..\components\drivers_nrf\common;..\..\..\..\..\..\components\drivers_nrf\config;..\..\..\..\..\..\components\drivers_nrf\delay;..\..\..\..\..\..\components\drivers_nrf\gpiote;..\..\..\..\..\..\components\drivers_nrf\hal;..\..\..\..\..\..\components\drivers_nrf\pstorage;..\..\..\..\..\..\components\drivers_nrf\uart;..\..\..\..\..\..\components\libraries\button;..\..\..\..\..\..\components\libraries\experimental_section_vars;..\..\..\..\..\..\components\libraries\fifo;..\..\..\..\..\..\components\libraries\fstorage;..\..\..\..\..\..\components\libraries\fstorage\config;..\..\..\..\..\..\components\libraries\timer;..\..\..\..\..\..\components\libraries\uart;..\..\..\..\..\..\components\libraries\util;..\..\..\..\..\..\components\softdevice\common\softdevice_handler;..\..\..\..\..\..\components\softdevice\s132\headers;..\..\..\..\..\..\components\softdevice\s132\headers\nrf52;..\..\..\..\..\..\components\toolchain;..\..\..\..\..\bsp;..\..\..\..\..\..\external\segger_rtt;..\..\..\kernel0.12.1;..\..\..\kernel0.12.1\include;..\..\..\config\ble_app_uart_s132_pca10040;..\..\..\kernel0.12.1\lib\i2c;..\..\..\..\..\..\components\drivers_nrf\twi_master;..\..\..\..\..\..\components\drivers_nrf\spi_master;..\..\..\..\..\..\components\drivers_nrf\saadc;..\..\..\..\..\..\components\drivers_nrf\timer;..\..\..\kernel0.12.1\driver\misc\pmu\bq25120;..\..\..\algorithm
  asm define: BLE_STACK_SUPPORT_REQD BOARD_PCA10040 NRF52_PAN_12 NRF52_PAN_15 NRF52_PAN_20 NRF52_PAN_30 NRF52_PAN_31 NRF52_PAN_36 NRF52_PAN_51 NRF52_PAN_53 NRF52_PAN_54 NRF52_PAN_55 NRF52_PAN_58 NRF52_PAN_62 NRF52_PAN_63 NRF52_PAN_64 CONFIG_GPIO_AS_PINRESET S132 NRF_LOG_USES_UART=1 NRF52 SOFTDEVICE_PRESENT SWI_DISABLE0
  library: MicroLIB
  memory RVCT4: ROM 0x1c000 size 0x64000
  memory RVCT9: RAM 0x20002080 size 0xdf80
  group Application
    ../../../: main.c app_nus_data.c temperature_parse.c
  group Board Support
    ../../../../../bsp/: bsp.c bsp_btn_ble.c
  group Documentation
    ../../../: Abstract.txt license.txt
  group nRF_BLE
    ../../../../../../components/ble/common/: ble_advdata.c ble_conn_params.c ble_srv_common.c
    ../../../../../../components/ble/ble_advertising/: ble_advertising.c
    ../../../../../../components/ble/ble_services/ble_nus/: ble_nus.c
  group nRF_Drivers
    ../../../../../../components/drivers_nrf/twi_master/: nrf_drv_twi.c
    ../../../../../../components/drivers_nrf/delay/: nrf_delay.c
    ../../../../../../components/drivers_nrf/common/: nrf_drv_common.c
    ../../../../../../components/drivers_nrf/gpiote/: nrf_drv_gpiote.c
    ../../../../../../components/drivers_nrf/uart/: nrf_drv_uart.c
    ../../../../../../components/drivers_nrf/pstorage/: pstorage.c
    ../../../../../../components/drivers_nrf/spi_master/: nrf_drv_spi.c
    ../../../: drv_kxo22.c
    ../../../../../../components/drivers_nrf/hal/: nrf_saadc.c
    ../../../../../../components/drivers_nrf/saadc/: nrf_drv_saadc.c
    ../../../../../../components/drivers_nrf/timer/: nrf_drv_timer.c
  group nRF_Libraries
    ../../../../../../components/libraries/uart/: app_uart_fifo.c retarget.c
    ../../../../../../components/libraries/button/: app_button.c
    ../../../../../../components/libraries/util/: app_error.c app_error_weak.c app_util_platform.c nrf_assert.c nrf_log.c
    ../../../../../../components/libraries/fifo/: app_fifo.c
    ../../../../../../components/libraries/timer/: app_timer.c
    ../../../../../../components/libraries/fstorage/: fstorage.c
    ../../../../../../components/libraries/scheduler/: app_scheduler.c
  group nRF_Segger_RTT
    ../../../../../../external/segger_rtt/: RTT_Syscalls_KEIL.c SEGGER_RTT.c SEGGER_RTT_printf.c
  group nRF_SoftDevice
    ../../../../../../components/softdevice/s132/doc/: s132_nrf52_2.0.0_licence_agreement.txt
    ../../../../../../components/softdevice/common/softdevice_handler/: softdevice_handler.c
  group Kernel0.12.1
    ../../../kernel0.12.1/core/: board.c buffer.c cache.c delay.c device.c init.c irq.c lock.c msg.c wait.c time.c task.c
    ../../../kernel0.12.1/driver/block/: block.c drive.c genhd.c
    ../../../kernel0.12.1/driver/flash/: flash_core.c
    ../../../kernel0.12.1/driver/flash/nand/: nand_core.c nrfs_nand.c
    ../../../kernel0.12.1/driver/gpio/: gpio.c
    ../../../kernel0.12.1/driver/i2c/: i2c_boardinfo.c i2c_core.c
    ../../../kernel0.12.1/driver/i2c/nordic/: nrfs_i2c.c
    ../../../kernel0.12.1/driver/misc/: misc.c
    ../../../kernel0.12.1/driver/platform/: platform.c
    ../../../kernel0.12.1/driver/spi/: spi_core.c
    ../../../kernel0.12.1/driver/uart/: uart.c nrfs_uart.c
    ../../../kernel0.12.1/fs/core/: fs.c inode.c mount.c open.c readdir.c
    ../../../kernel0.12.1/fs/devfs/: char_dev.c devfs.c
    ../../../kernel0.12.1/fs/lxtfs/: lxtfs.c
    ../../../kernel0.12.1/fs/ramfs/: ramfs.c
    ../../../kernel0.12.1/lib/extra/: getopt.c strex.c
    ../../../kernel0.12.1/lib/kobject/: kobject.c
    ../../../kernel0.12.1/lib/std/: stdio.c string.c
    ../../../kernel0.12.1/lib/unistd/: dir.c
    ../../../kernel0.12.1/shell/: shell.c
    ../../../kernel0.12.1/shell/command/: cat.c cd.c echo.c factory.c gpio2s.c help.c info.c ls.c mkdir.c mklxtfs.c mountfs.c rm.c sync.c touch.c xdb.c clear.c fbtools.c
    ../../../kernel0.12.1/core/sched/: sched.c sched_common.c
    ../../../kernel0.12.1/mm/heap/: malloc.c
    ../../../kernel0.12.1/driver/misc/gexpander/tca7408/: tca7408.c
    ../../../kernel0.12.1/driver/misc/vibrator/drv2605/: drv2605.c
    ../../../kernel0.12.1/driver/spi/nrfs_spi/: nrfs_spi.c
    ../../../kernel0.12.1/driver/misc/lcm/: lcm_drv.c
    ../../../kernel0.12.1/driver/misc/lcm/uc8151/: uc8151.c
    ../../../kernel0.12.1/driver/gpio/nrfs_gpio/: nrfs_gpio.c
    ../../../kernel0.12.1/driver/display/: fbmem.c display_core.c nrfsfb.c nrfs_diaplay.c
    ../../../kernel0.12.1/driver/misc/pmu/bq25120/: bq25120.c
    ../../../kernel0.12.1/driver/misc/mtk/mt2502/: mt2502.c mt2502_msg.c
    ../../../kernel0.12.1/lib/display/font/: font_uc8151.c
    ../../../kernel0.12.1/lib/fs/: fopen.c
    ../../../project/PAGER_B3710/: pager_init.c
    ../../../kernel0.12.1/driver/misc/thermometer/PNM723T703E0_2/: pnm723t.c
    ../../../kernel0.12.1/driver/misc/greenray/pps960/: pps960.c
    ../../../kernel0.12.1/driver/power/: power.c
    ../../../kernel0.12.1/lib/time/: localtime.c
    ../../../kernel0.12.1/driver/button/: button.c
    ../../../kernel0.12.1/driver/misc/button/: button3710.c
  group Pager Application
    ../../../project/PAGER_B3710/: pager_measure.c pager_task.c pager_msg.c pager_time.c pager_alarm.c pager_ui.c pager_font_20x27.c pager_log.c pager_file_manager.c pager_logo_24x24.c pager_font_64x15.c pager_font_72x20.c pager_logo_24x4.c pager_logo_other.c
  group algorithm
    ../../../algorithm/: Algorithm.lib
target flash_s132_nrf52_2.0.0_softdevice (ARM-ADS)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.6.1
  cpu: as above
  output: s132_nrf52_2.0.0_softdevice.hex +hex
  c flags: Optim=4 OneElfS=1 uC99=1
  c include: ..\..\..\config\ble_app_uart_s132_pca10040;..\..\..\config
  library: MicroLIB
  memory RVCT4: ROM 0x1c000 size 0x64000
  memory RVCT9: RAM 0x20002080 size 0xdf80
software components: CMSIS:CORE 4.3.0, Device:Startup 8.5.0
